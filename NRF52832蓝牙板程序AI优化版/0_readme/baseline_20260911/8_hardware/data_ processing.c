#include "data_processing.h"
#include <stdlib.h>
#include "stdint.h"
#include <errno.h>
#include "stdbool.h"
#include "string.h"
#include "my_printf.h"
//*****************************************************************************************************************
uint8_t  feature_raw[32]= {0};       // 用于保存在feature_set 函数中转换好的十六进制值
uint8_t  feature_raw_len = 0;        // 用于保存在feature_set 函数中转换好的十六进制的个数
bool feature_global_flag = false ;   //  用于保存 feature_set 函数转换是否成功的标志，  真 = 转换ok


// 加解密密码表
const unsigned char encrypt_key[255] = 
{
      93,104,182,158,107,45,225,8,238,216,83,108,34,74,17,79,221,
      54,51,124,38,14,155,23,156,184,151,63,131,168,140,13,12,185,
      58,235,98,237,5,165,2,204,19,250,175,53,68,9,6,39,248,181,90,
      92,48,207,127,77,147,219,242,199,16,133,67,186,18,66,239,57,
      201,231,146,123,97,95,191,3,71,214,234,215,223,217,169,41,222,
      85,157,117,7,89,240,161,129,72,137,73,149,167,174,121,144,84,
      70,195,152,10,62,198,243,145,91,236,244,120,100,94,209,212,25,
      60,218,59,229,119,138,245,75,226,103,220,31,116,230,26,29,210,
      109,135,80,56,196,24,46,50,11,36,81,194,110,162,102,200,211,172,
      160,69,118,33,113,134,86,197,164,205,142,65,170,44,154,37,136,47,
      64,15,183,254,150,190,82,76,1,246,178,30,192,241,40,233,171,251,
      159,255,173,111,224,177,87,179,122,208,228,78,128,43,227,99,206,
      28,96,247,21,180,42,125,114,20,189,148,193,27,88,32,61,132,188,
      176,166,213,141,22,106,35,112,4,249,202,115,252,52,203,232,49,
      126,105,101,187,143,163,139,153,55,253,130
};

//*****************************************************************************************************************


/*******************************************************************
********************************************************************
* 名称：
* 功能：判断接收到的广播包中的31个数据是否完整
* 参数：data_string ： 待判断的广播包数据
       string_len : 广播包的数据长度
* 返回值：
        true  =  数据完整
        false = 数据接收有误
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/
static bool check_sum(uint8_t * data_string,unsigned char string_len)
{
    uint8_t sum = 0 ;        // 保存累加和
    if( string_len < 31)  // 入参的字符长度判断， 小于31的，直接返回
    {
        return false ;
    }
    for(char i = 0 ; i <= 21 ; i++)  // 0--21 一共22个数字参与校验和计算
    {
        sum += data_string[i+9] ;  // 从data 的第9位开始，第9位是 encrypt idx
    }
    if(sum == data_string[8] )  //  data  的第8位是广播的校验和
    {
//        print("check_sum = %02X\r\n",sum);
        return true ;
    }
    else
    {
        return false ;
    }
    
}
/*******************************************************************
********************************************************************
* 名称：
* 功能： 解密数据，并将数据保存起来
* 参数：
        data_string : 待解密数据指针
        string_len  : 待解密数据的长度
        target_buf ： 解密ok的数据保存地址指针
        buf_size   ：保存解密数据的数组长度 
* 返回值：
         true = 解密ok
         false = 解密失败
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/
bool  decrypt_data(uint8_t * data_string, unsigned char string_len, uint8_t * target_buf, int buf_size)
{
    uint8_t   encrypt_idx = 0 ;          // 用于保存原始数据中的码表起始位置
    memset(target_buf,'\0',buf_size);
    if(buf_size < 22 )
    {
        return false ;
    }
    
    if(check_sum(data_string,string_len) == true)   // 待解密的数据完整有效时
    {
        encrypt_idx = data_string[9];    //  从原始数据中取出码表开始位置
        // encrypt_indx为随机数(小于等于255-21)
        if(encrypt_idx > (255 - 21))    // encrypt_idx + 20 不能越界，encrypt_key 共 255 个元素
        {
            return false;               // 拒绝处理异常索引
        }
//        print("encrypt_idx = %02X\r\n",encrypt_idx);
        for(unsigned char i = 0 ; i < 21 ; i++)   //  对payload 为 21的数据根据码表异或解密
        {
            target_buf[i] = data_string[i + 10] ^ encrypt_key[encrypt_idx + i ] ;   // 异或解密数据并保存到data_buf
        }
        target_buf[21] = '\0';             //  最后加上结束字符
        return true ;
    }
    else
    {
        return false ;
    }
}

/*******************************************************************
********************************************************************
* 名称：
* 功能：
* 参数：
* 返回值：
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/



/*******************************************************************
********************************************************************
* 名称：
* 功能：将纯数字字符串转换为对应进制的数值并返回，且如果ok_ng =true 为真成功
* 参数：p_numchar：  指向待转换的字符串（纯数字串）
        ok_ng   :  转换结果表示， 真转换ok， 否则失败
        base     ： 进制  10 = 十进制， 16 = 十六进制  0=自动识别，0x开头=16进制，0开头=8进制
* 返回值：
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/
long num_str_to_num(char *p_numchar,bool *ok_ng,uint8_t base)
{
    char *end ;
    errno = 0 ;
    long value = strtol(p_numchar, &end, base);  // 可检测溢出，推荐
    if(*end == '\0')  // 转换成功
    {
        *ok_ng = true ;  // 转换函数没有问题  （ok_ng 为value 值是否可用的判断依据）
        return value ;  // 返回转换后的值
    }
    else
    {
        *ok_ng = false ;  // 转换函数转换失败
        return 0 ;        // 返回0
    }
}
/*******************************************************************
********************************************************************
* 名称：
* 功能：从源字符串中查找从指定的开始字符开始，带指定的结束字符串之间的字符串
* 参数：
* 返回值：
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/
bool str_extract(const char *src,                                      // 源字符串
                 const char *start,                                    // 起始标记
                 const char *end,                                      // 结束标记
                 char *dst)                                            // 保存找到的字符串
{
    const char *p1 = strstr(src, start);                               // 查找起始标记位置
    if (!p1)
    {
        return false;                                                  // 没找到起始标记 → 失败
    }    
    p1 += strlen(start);                                               // 跳过起始标记，指向内容开头

    const char *p2 = strstr(p1, end);                                  // 从内容开头查找结束标记
    if (!p2)                                                           // 找到了end字符串
    {
        return false;                                                  // 没找到结束标记 → 失败
    }

    size_t len = p2 - p1;                                              // 计算中间内容的长度
    memcpy(dst, p1, len);                                              // 拷贝内容到输出区
    dst[len] = '\0';                                                   // 补上字符串结束符
    return true;                                                       // 提取成功
}

/*******************************************************************
********************************************************************
* 名称：
* 功能： 将十六进制字符串转换为十六进制的数保存在feature_raw，
* 参数： hex_str =待转换的十六进制字符串（且字符个数要是偶数）
* 返回值：
* 版本：v1
* 作者：matt
* 日期：2026-06-06
* 举例：
* 备注：
* 
* 
*********************************************************************
*********************************************************************/
void feature_set(const char *hex_str)
{
    char *end ;   // 保存 strtol 转换的结果
    feature_raw_len = 0;    //  函数中转换好的十六进制的个数 （先清0 ）
    size_t len = strlen(hex_str);   // 获取将要转换的十六进制的字符串 长度
    if (len % 2 != 0)
    {
        return;                    // 奇数个字符 → 非法输入，丢弃
    }        
    for (size_t i = 0; i < len; i += 2) // 每次取 2 个字符转 1 字节
    {
        char buf[3] = {hex_str[i], hex_str[i+1], '\0'};
        feature_raw[feature_raw_len++] = (uint8_t)strtol(buf, &end, 16); // 转成字节并存入数组，长度 +1  （strtol 将 02，转换成0x02）
        if(*end == '\0')  // 转换成功
        {
            feature_global_flag = true;
        }
    }
}

