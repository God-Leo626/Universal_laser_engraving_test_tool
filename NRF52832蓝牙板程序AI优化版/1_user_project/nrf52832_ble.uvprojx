# Keil uVision project nrf52832_ble.uvprojx, settings and files
target my_borad (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: my_nrf52832 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NRFX_UARTE_ENABLED=1,NRFX_UARTE0_ENABLED=1,NRF52832_XXAA,CONFIG_GPIO_AS_PINRESET,NRF52,NRF_SD_BLE_API_VERSION=6,SOFTDEVICE_PRESENT,S132,SWI_DISABLE0,__STACK_SIZE=8192,__HEAP_SIZE=8192
  c misc: --reduce_paths
  c include: ..\1_user_project;..\4_integration\nrfx;..\4_integration\nrfx\legacy;..\5_modules\nrfx;..\5_modules\nrfx\mdk;..\5_modules\nrfx\hal;..\5_modules\nrfx\drivers\include;..\5_modules\nrfx\drivers\src\prs;..\5_modules\nrfx\drivers\src;..\3_external\fprintf;..\3_external\segger_rtt;..\2_components;..\2_components\libraries\delay;..\2_components\libraries\util;..\2_components\libraries\strerror;..\2_components\libraries\mutex;..\2_components\libraries\log;..\2_components\libraries\log\src;..\2_components\libraries\experimental_section_vars;..\2_components\libraries\memobj;..\2_components\libraries\balloc;..\2_components\libraries\ringbuf;..\2_components\libraries\uart;..\2_components\libraries\atomic;..\2_components\libraries\fifo;..\2_components\libraries\atomic_fifo;..\2_components\libraries\button;..\2_components\libraries\crc16;..\2_components\libraries\timer;..\2_components\libraries\scheduler;..\2_components\libraries\fds;..\2_components\libraries\hardfault;..\2_components\libraries\atomic_flags;..\2_components\ble\peer_manager;..\2_components\ble\ble_db_discovery;..\2_components\libraries\fstorage;..\8_hardware;..\9_nrf52832_ble
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002218 size 0xdde8
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group 1_user_porject
    ./: main.c sdk_config.h
    ../0_readme/: readme20260711.txt
  group 3_libraries
    ../2_components/libraries/util/: nrf_assert.c app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c
    ../2_components/libraries/strerror/: nrf_strerror.c
    ../3_external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../2_components/libraries/ringbuf/: nrf_ringbuf.c
    ../2_components/libraries/memobj/: nrf_memobj.c
    ../2_components/libraries/atomic/: nrf_atomic.c
    ../2_components/libraries/balloc/: nrf_balloc.c
    ../5_modules/nrfx/drivers/src/: nrfx_uarte.c nrfx_timer.c nrfx_gpiote.c nrfx_ppi.c nrfx_clock.c nrfx_power_clock.c
    ../4_integration/nrfx/legacy/: nrf_drv_clock.c
    ../5_modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../2_components/libraries/crc16/: crc16.c
    ../2_components/libraries/fds/: fds.c
    ../2_components/libraries/hardfault/: hardfault_implementation.c
    ../2_components/libraries/atomic_fifo/: nrf_atfifo.c
    ../2_components/libraries/atomic_flags/: nrf_atflags.c
    ../2_components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../2_components/libraries/scheduler/: app_scheduler.c
    ../2_components/libraries/timer/: app_timer.c
    ../2_components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../2_components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../2_components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group 5_segger_RTT
    ../3_external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group 8_hardware
    ../8_hardware/: buzzer.c led.c button.c touch_pad.c my_printf.c timer.c gpiote.c ppi.c uarte_52832_dma.c ble_app.c data_processing.c app_config.c uart_commands.c adv_parser.c
  group 9_nrf52832_ble
    ../9_nrf52832_ble/: auth_status_tracker.c ble_advdata.c ble_advertising.c ble_conn_params.c ble_conn_state.c ble_srv_common.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_gatt.c nrf_ble_qwr.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c ble_db_discovery.c nrf_ble_scan.c
target s132_nrf52_6.1.0_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NRFX_UARTE_ENABLED=1,NRFX_UARTE0_ENABLED=1,NRF52832_XXAA
  c misc: --reduce_paths
  c include: ..\1_user_project;..\4_integration\nrfx;..\4_integration\nrfx\legacy;..\5_modules\nrfx;..\5_modules\nrfx\hal;..\5_modules\nrfx\drivers\include;..\3_external\fprintf;..\3_external\segger_rtt;..\2_components;..\2_components\drivers_nrf\nrf_soc_nosd;..\2_components\libraries\delay;..\2_components\libraries\util;..\2_components\libraries\strerror;..\2_components\libraries\log;..\2_components\libraries\log\src;..\2_components\libraries\experimental_section_vars;..\2_components\libraries\memobj;..\2_components\libraries\balloc;..\2_components\libraries\ringbuf;..\2_components\libraries\atomic;..\2_components\libraries\uart;..\2_components\libraries\fifo;..\8_hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x26000
  memory RVCT9: RAM 0x20000000 size 0x2218
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.5.0, CMSIS:CORE 4.3.0, Device:Startup 8.17.0, Device:Startup 8.40.3
