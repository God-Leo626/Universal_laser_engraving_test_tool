# Keil uVision project coolkit_test_board_stm32f407.uvprojx, settings and files
target ble_passive_scanning (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: coolkit_test_board_stm32f407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\1_user;..\3_stm32f407_fwlib\inc;..\6_hardware;..\8_Free_RTOS\include;..\8_Free_RTOS\Free_RTOS_portable
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_memory.sct
  group 0_README
    ../0_readme/: readme20221219.txt
  group 1_USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group 3_STM32F40X_FWLIB
    ../3_stm32f407_fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group 4_STM32F40X_STARTUP
    ../4_stm32f407_startup/: startup_stm32f40_41xxx.s
  group 8_FREE_RTOS_CORE
    ../8_Free_RTOS/FreeRTOS_core/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group 8_FREE_RTOS_PROTABLE
    ../8_Free_RTOS/Free_RTOS_portable/: port.c heap_4.c
  group 6_APP_PROTOCOL
    ../6_hardware/: my_task.c my_task.h app_protocol.h data_processing.c data_processing.h
  group 6_SERIAL_DMA
    ../6_hardware/: usart_ring_buff.c usart_ring_buff.h usart_dma_all.c usart_dma_all.h dma.c dma.h variable_global.c variable_global.h uart_select.c
  group 6_DISPLAY_INPUT
    ../6_hardware/: ui_lcd.c lcd.c font.c coolkit_logo_133x87.c button.c time3.c buzzer.c
  group 6_BOARD_STORAGE
    ../6_hardware/: fixture_start.c systick_delay_freerots.c power_ctrl.c spi1.c spi2.c w25q32.c
